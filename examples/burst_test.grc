<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>sample_rate</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1e6</value></param>
<param><key>step</key><value>0.1e6</value></param>
<param><key>stop</key><value>max_sample_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>burst_interval_range</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Burst Interval</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>burst_length_range</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Burst Length</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>6000e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>55</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>76</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_sample_rate</value></param>
<param><key>value</key><value>56e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.1e6</value></param>
<param><key>step</key><value>0.1e6</value></param>
<param><key>stop</key><value>max_sample_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_min_output_buffer</value></param>
<param><key>value</key><value>2**14*2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_rate_0</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>variable_function_probe_0</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>label</key><value>Rx Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vector_length</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>sidekiq_sidekiq_tx</key>
<param><key>id</key><value>sidekiq_sidekiq_tx_0</value></param>
<param><key>card</key><value>0</value></param>
<param><key>attenuation</key><value>gain</value></param>
<param><key>bandwidth</key><value>bandwidth</value></param>
<param><key>buffer_size</key><value>1020</value></param>
<param><key>dataflow_mode</key><value>1</value></param>
<param><key>filter_override_taps</key><value></value></param>
<param><key>frequency</key><value>center_freq</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>suppress_tune_transients</key><value>bool(1)</value></param>
<param><key>sync</key><value>1</value></param>
</block>
<block>
<key>sidekiq_tx_burst_test</key>
<param><key>id</key><value>sidekiq_tx_burst_test_0</value></param>
<param><key>burst_interval_millis</key><value>burst_interval_range</value></param>
<param><key>burst_length_millis</key><value>burst_length_range</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>telemetry_message</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>telemetry_message</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>sidekiq_sidekiq_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sidekiq_sidekiq_tx_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>telemetry</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sidekiq_sidekiq_tx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>telemetry</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>sidekiq_tx_burst_test_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>sidekiq_tx_burst_test_0</sink_block_id><source_key>out</source_key><sink_key>telemetry</sink_key></connection>
</flow_graph>
